# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\FINGERPRINT;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\SYSTEM\communication;..\SYSTEM\ds1302;..\HARDWARE\DMA;..\HARDWARE;..\SYSTEM\fingerRead;..\SYSTEM\FIFO
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/FINGERPRINT/: fingerprint.c
    ../HARDWARE/DMA/: dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/Communication/: Communication.c
    ../SYSTEM/ds1302/: ds1302.c
    ../SYSTEM/fingerRead/: fingerRead.c
    ../SYSTEM/FIFO/: FIFO.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_dma.c
